File: Clock/LedDisplay.kicad_sch (KiCad schematic)
At the start: 71 parts

Commit message: update PCB 09/1/2022
Parts:
- gave numbers to parts that had none: 71
